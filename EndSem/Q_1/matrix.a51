ORG 0H
LJMP MAIN
 
ORG 30H
MAIN:
MOV R3,30H
MOV R4,30H

MOV R0,#31H

MOV A,#0
MOV R2,30H
SQUARE :
ADD A,30H
DJNZ R2,SQUARE
ADD A,#31H
MOV R1,A

LOOP :
MOV R4,30H
HERE : 
MOV A,@R0
MOV B,@R1
ADD A,B
MOV B,A

MOV A,R1
MOV R2,30H
SUM :
ADD A,30H
DJNZ R2,SUM
MOV R1,A
MOV @R1,B

MOV R2,30H
SUB :
SUBB A,30H
DJNZ R2,SUB
MOV R1,A

INC R0
INC R1
DJNZ R4,HERE
DJNZ R3,LOOP

SJMP $

END