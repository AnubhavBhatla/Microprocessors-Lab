ORG 0H
LJMP CONVERT

ORG 100H
CONVERT:
	MOV A,30H
	ANL A,#0FH
	MOV R2,A
	ACALL CHECK
	MOV 61H,A
	
	MOV A,30H
	ANL A,#240
	SWAP A
	MOV R2,A
	ACALL CHECK
	MOV 60H,A
	
	HERE : SJMP HERE
	
	CHECK:
	CLR C
	SUBB A,#0AH
	JC NUM
	ADD A,#41H
	LABEL1 : RET
	NUM :
	MOV A,R2
	ADD A,#30H
	SJMP LABEL1
	
END